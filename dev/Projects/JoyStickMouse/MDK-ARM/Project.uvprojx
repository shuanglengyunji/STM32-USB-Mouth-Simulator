# Keil uVision project Project.uvprojx, settings and files
target STM3210B-EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210B-EVAL
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_STM3210B_EVAL
  c misc: --C99
  c include: ../inc;../../../Libraries/CMSIS/Device/ST/STM32F10x/Include;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Libraries/STM32F10x_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL;../../../Utilities/STM32_EVAL/Common;../../../Utilities/STM32_EVAL/STM3210B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../src/: main.c hw_config.c stm32_it.c
  group STM32F10x/STM3210B_EVAL
    ../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval.c
  group Usb Config
    ../src/: usb_pwr.c usb_istr.c usb_desc.c usb_endp.c usb_prop.c
  group Doc
    ../: readme.txt
  group STM32F10x/CMSIS
    ./: startup_stm32f10x_md.s startup_stm32f10x_hd.s
    ../src/: system_stm32f10x.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_sil.c usb_regs.c usb_int.c usb_core.c usb_mem.c usb_init.c
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_spi.c
software components: CMSIS:CORE 5.0.1
